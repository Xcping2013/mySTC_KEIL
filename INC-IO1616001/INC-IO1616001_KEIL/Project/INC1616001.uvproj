# Keil uVision project INC1616001.uvproj, settings and files
target X2B_MP (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: INC1616001 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\inc
  group Source
    ../src/: commands.c Delay.c EEPROM.c Uart1.c X2B_MP.C IIC_Soft.c
  group Include
    ../inc/: commands.h IO.h STC12C5A60S2.H IIC_Soft.h
  group Doc
    ./: Readme.txt
