# Keil uVision project INC1212001.uvproj, settings and files
target INC1212001 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: INC1212001 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Inc;..\User
  group User
    ../User/: Main.h Main.c
  group Src
    ../src/: Delay.c IO.C
    ../Src/: Timer.c EEPROM_OnChip.c UART.c SysControl.c IIC_Soft.c 24CXX.c Commands.c
  group Inc
    ../Inc/: STC12C5A60S2.H Delay.h Timer.h EEPROM_OnChip.h UART.h IO.h SysControl.h IIC_Soft.h 24CXX.h Commands.h
